# Keil uVision project demo.uvproj, settings and files
target SC51F33xx (MCS-51)
  device: SC51F3364 silan
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xFFFF) CLOCK(2000000) MODP2
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group 소스파일
    ../Source/: common.c crt.c flash.c function_key.c hal.c main.c ram.c rom.c special.c sysclk.c
  group 리소스
    ../Source/DB/: DATA.A51
